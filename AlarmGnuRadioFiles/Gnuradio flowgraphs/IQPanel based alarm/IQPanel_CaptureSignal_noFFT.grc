<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>319.5e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>(channel_spacing/2)+(channel_spacing * .1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_spacing</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>freq+freq_offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>if_gain0</key><value>24</value></param>
<param><key>bb_gain0</key><value>30</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>FileCapture</value></param>
<param><key>file</key><value>/home/user/AlarmGnuRadioFiles/Captured/Capture_IQPanel_BasementPIR.cap</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>FileCapture</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pathprefix</value></param>
<param><key>value</key><value>"/home/user/AlarmGnuRadioFiles/Captured/"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>433.92e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_spacing</value></param>
<param><key>value</key><value>3000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>(channel_spacing/2)+(channel_spacing * .1)</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>freq+freq_offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>20</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>True</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>FileCapture</value></param>
<param><key>file</key><value>pathprefix+"Unfiltered_Capture"+datetime.now().strftime("%Y.%m.%d.%H.%M.%S") +".dat"</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>FileCapture</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
